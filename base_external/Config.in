## base_external/Config.in
```kconfig
source "$BR2_EXTERNAL_project_sz_base_PATH/package/aesd-assignments/Config.in"
source "$BR2_EXTERNAL_project_sz_base_PATH/package/ldd/Config.in"
```
